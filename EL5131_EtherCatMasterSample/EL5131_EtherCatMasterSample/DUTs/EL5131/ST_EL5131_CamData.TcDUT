TYPE ST_EL5131_CamData :
STRUCT
	bOutputState		:	BOOL;
	nDuration			:	UDINT;
	nPos				:	UDINT;
END_STRUCT
END_TYPE
